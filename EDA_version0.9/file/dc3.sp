R1 1 0 1
R2 1 2 0.5
D1 2 0  D1N4148
I1 0 1 1
.DC I1 1 5 1
