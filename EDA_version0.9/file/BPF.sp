BPF
V1 1 0 10
R1 1 2 3
L1 2 0 100u
C1 2 0 1m
.AC dec 10 1 8k
