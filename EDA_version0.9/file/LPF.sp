LPF
V1 1 0 10
L1 1 2 1m
R1 2 0 3
C1 2 0 300u
.AC dec 10 1 10k
