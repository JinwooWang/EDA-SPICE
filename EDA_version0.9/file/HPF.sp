HPF
V1 1 0 10
C1 1 2 1m
R1 2 0 3
L1 2 0 5m
.AC dec 10 1 8k
